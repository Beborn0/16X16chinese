# Keil uVision project MAX7219.uvproj, settings and files
target MAX7219 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MAX7219 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: main.c max7219.h max7219.c
